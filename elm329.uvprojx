# Keil uVision project elm329.uvprojx, settings and files
target adapter (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F042K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: obdst18 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=3 wLevel=2
  c misc: -DHSE_VALUE2=12000000 -DSTM32F042x6 -DPLL_SOURCE_HSI
  c include: .\src\drv\stm32f0xx;.\src\util;.\STM32F0xx_StdPeriph_Driver\inc;.\src\adapter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group app
    ./src/adapter/: adapter.cpp adapterconfig.cpp datacollector.cpp functions.cpp dispatcher.cpp
  group driver
    ./src/drv/stm32f0xx/: AdcSTM32F0xx.cpp CanDriverSTM32F0xx.cpp CmdUartSTM32F0xx.cpp SysutilitySTM32F0xx.cpp GpioDrvSTM32F0xx.cpp TimerSTM32F0xx.cpp led.cpp
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_can.c stm32f0xx_adc.c
  group obd
    ./src/adapter/obd/: autoadapter.cpp canformatter.cpp canhistory.cpp isocan.cpp obdprofile.cpp padapter.cpp
  group util
    ./src/util/: algorithms.cpp canmsgbuffer.cpp lstring.cpp
software components: CMSIS:CORE 4.2.0, Device:Startup 1.5.0
